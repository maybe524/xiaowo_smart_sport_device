# Keil uVision project lis3dh.uvprojx, settings and files
target IK-52832DK (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.17.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: nrf52832_qfaa +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: BOARD_PCA10040 BSP_DEFINES_ONLY CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD NRF52 NRF52832_XXAA NRF52_PAN_74 __HEAP_SIZE=8192 __STACK_SIZE=8192
  c misc: --reduce_paths
  c include: ..\config;..\..\modules\nrfx;..\..\integration\nrfx;..\..\modules\nrfx\hal;..\..\modules\nrfx\mdk;..\..\components\boards;..\..\components\drivers_nrf\nrf_soc_nosd;..\..\components\libraries\delay;..\..\components\libraries\util;..\..\components\libraries\strerror;..\..\components\libraries\log;..\..\components\libraries\log\src;..\..\components\libraries\experimental_section_vars;..\..\components\libraries\experimental_memobj;..\..\components\libraries\balloc;..\..\components\libraries\uart;..\..\components\libraries\fifo;..\..\integration\nrfx\legacy;..\..\modules\nrfx\drivers\include;..\..\app\lis3dh
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application
    ../../app/: main.c
    ../config/: sdk_config.h
    ../../app/lis3dh/: lis3dh_drive.c
  group Board Definition
    ../../components/boards/: boards.c
  group nRF_Drivers
    ../../modules/nrfx/drivers/src/: nrfx_uarte.c nrfx_uart.c nrfx_spi.c nrfx_spim.c
    ../../modules/nrfx/drivers/src/prs/: nrfx_prs.c
    ../../integration/nrfx/legacy/: nrf_drv_uart.c nrf_drv_spi.c
  group nRF_Libraries
    ../../components/libraries/util/: app_error.c app_error_handler_keil.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../../components/libraries/strerror/: nrf_strerror.c
    ../../components/libraries/uart/: app_uart_fifo.c retarget.c
    ../../components/libraries/fifo/: app_fifo.c
  group Doc
    ../../doc/: 说明.txt
software components: CMSIS:CORE 4.3.0, Device:Startup 8.17.0
